options:
  parameters:
    generate_options: qt_gui
    id: fft
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '435934186'
  states: {}
- name: constant
  id: variable_qtgui_range
  parameters:
    start: '-1'
    step: '0.01'
    stop: '1'
    value: '-0.02'
  states: {}
- name: cutoff_freq
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: high
  id: variable
  parameters:
    value: center_freq + 5000
  states: {}
- name: loop_bw
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.0251'
  states: {}
- name: low
  id: variable
  parameters:
    value: center_freq-5000
  states: {}
- name: lpf_deci
  id: variable
  parameters:
    value: '4'
  states: {}
- name: qd_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '20'
    value: '16'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: squelch
  id: variable
  parameters:
    value: '-50'
  states: {}
- name: ted_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {}
- name: transition_width
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    comment: Normalize the signal for clock recovery
    gain: '0.6'
    max_gain: '65536'
    rate: '1e-4'
    reference: '0.6'
    type: float
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: qd_gain
  states: {}
- name: analog_simple_squelch_cc_1
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-32'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: constant
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/njreichert/a.bin
    type: byte
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: lpf_deci
    type: complex
  states: {state: disabled}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: lpf_deci
    type: complex
  states: {state: disabled}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {state: disabled}
- name: digital_binary_slicer_fb_2_0
  id: digital_binary_slicer_fb
  parameters:
    comment: Make signal digital
  states: {}
- name: digital_clock_recovery_mm_xx_1
  id: digital_clock_recovery_mm_xx
  parameters:
    comment: Recover the signal clock
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: (sample_rate/lpf_deci) / baud_rate
    omega_relative_limit: '0'
    type: float
  states: {}
- name: digital_symbol_sync_xx_1
  id: digital_symbol_sync_xx
  parameters:
    constellation: digital.constellation_qpsk().base()
    damping: '1.5'
    loop_bw: loop_bw
    max_dev: '10'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: (sample_rate / lpf_deci) / baud_rate
    ted_gain: ted_gain
    ted_type: digital.TED_EARLY_LATE
    type: ff
  states: {state: disabled}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '10000'
    decim: '1'
    gain: '1'
    samp_rate: sample_rate
    type: fir_filter_ccf
    width: transition_width
    win: window.WIN_HAMMING
  states: {state: bypassed}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff_freq
    decim: lpf_deci
    gain: '1'
    samp_rate: sample_rate
    type: fir_filter_ccf
    width: transition_width
    win: window.WIN_HAMMING
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1024'
    port: '2000'
    send_eof: 'False'
    type: byte
  states: {}
- name: note_0
  id: note
  parameters:
    note: samp_rate/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: 'The decoder block is pulled from this repository: https://github.com/joushx/gnuradio-fsk-demod'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '32768'
    nconnections: '3'
    tr_level: '-60'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    update_time: '0.001'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Quadrature Demod Output"'
    size: '10000'
    srate: sample_rate
    tr_delay: '0.0005'
    tr_level: '1'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Filter Output"'
    size: '10000'
    srate: sample_rate
    tr_delay: '0.0005'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Final Bits"'
    size: '10000'
    srate: sample_rate
    tr_delay: '0.0005'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_slope: qtgui.TRIG_SLOPE_NEG
    type: float
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Final Bits"'
    size: '10000'
    srate: sample_rate
    tr_delay: '0.0005'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_slope: qtgui.TRIG_SLOPE_NEG
    type: float
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Symbol Sync"'
    nconnections: '2'
    size: '10000'
    srate: sample_rate
    tr_delay: '0.0005'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '2.5'
    ymin: '-2.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Symbol Sync"'
    size: '10000'
    srate: sample_rate
    tr_delay: '0.0005'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ymax: '2.5'
    ymin: '-2.5'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sample_rate / lpf_deci
    fc: '0'
    fftsize: '32768'
    int_max: '-10'
    int_min: '-100'
    type: complex
    update_time: '0.001'
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    agc: 'True'
    center_freq: center_freq
    dev_args: '''driver=rtlsdr,manufacturer=Realtek,product=RTL2838UHIDIR,soapy=1,tuner=\''Rafael Micro R820T\'''''
    samp_rate: sample_rate
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_clock_recovery_mm_xx_1, '0']
- [analog_agc_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', blocks_add_const_vxx_0, '0']
- [analog_simple_squelch_cc_1, '0', analog_quadrature_demod_cf_0, '0']
- [analog_simple_squelch_cc_1, '0', blocks_repeat_0, '0']
- [analog_simple_squelch_cc_1, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_add_const_vxx_0, '0', analog_agc_xx_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_pack_k_bits_bb_0, '0', network_udp_sink_0, '0']
- [blocks_repeat_0, '0', qtgui_freq_sink_x_0, '2']
- [blocks_repeat_0_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_uchar_to_float_0_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_uchar_to_float_0, '0']
- [digital_binary_slicer_fb_2_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_binary_slicer_fb_2_0, '0', blocks_uchar_to_float_0_0, '0']
- [digital_clock_recovery_mm_xx_1, '0', digital_binary_slicer_fb_2_0, '0']
- [digital_clock_recovery_mm_xx_1, '0', qtgui_time_sink_x_0_0_1_0, '0']
- [digital_symbol_sync_xx_1, '0', digital_binary_slicer_fb_0, '0']
- [digital_symbol_sync_xx_1, '0', qtgui_time_sink_x_0_0_1, '0']
- [digital_symbol_sync_xx_1, '1', qtgui_time_sink_x_0_0_1, '1']
- [high_pass_filter_0, '0', low_pass_filter_1, '0']
- [low_pass_filter_1, '0', analog_simple_squelch_cc_1, '0']
- [low_pass_filter_1, '0', blocks_repeat_0_0, '0']
- [soapy_rtlsdr_source_0, '0', high_pass_filter_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
